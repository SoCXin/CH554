# Keil uVision project udisk.uvproj, settings and files
target qitas (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: udisk +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public
  group user
    ./: u_disk.c
    ./Public/: DEBUG.C
