# Keil uVision project CH340.uvproj, settings and files
target qtias (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: CH340 +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./Public/: Debug.C
    ./USB/Device/: CompatibilityHID.C
