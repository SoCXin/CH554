# Keil uVision project CH554.uvproj, settings and files
target USBHOST (MCS-51)
  device: CH554 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH554DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./Public/: Debug.C
    ./USB/USB_LIB/: USBHOST.C
    ./USB/Host/: USBHostHUB_KM.C
