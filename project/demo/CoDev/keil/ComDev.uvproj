# Keil uVision project ComDev.uvproj, settings and files
target qitas (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ComDev +hex
  c flags: Optimize=6 SizeSpeed=1
  group user
    ../user/: main.c DEBUG.C Compound.C Touch_Key.C
